# Keil uVision project AxioCrypto.uvprojx, settings and files
target AxioCrypto (6230000::V6.23::ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x30000000,0x40000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: AxioCrypto
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: Stack_Size=0x7000 Heap_Size=0x18000
  c include: ..\..\..\M2354BSP\Library\Device\Nuvoton\M2354\Include;..\..\..\M2354BSP\Library\CMSIS\Include;..\..\..\M2354BSP\Library\StdDriver\inc;..\..\lib\include
  asm define: Stack_Size=0x7000 Heap_Size=0x18000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\m2354.sct
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../M2354BSP/Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../M2354BSP/Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group User
    ../: main.c
  group Library
    ../../../M2354BSP/Library/StdDriver/src/: retarget.c sys.c clk.c uart.c timer.c fmc.c
  group AxioCryptoM
    ../../lib/include/: axiocrypto.h axiocrypto_defines.h axiocrypto_pqc.h
    ../../lib/: libaxiocrypto_1.0_m2354_ce.a
  group AxioCryptoM_Example
    ../../../axiocrypto_examples/: example.c example_axiocrypto.c example_pqc.c example_util.c example_util.h
