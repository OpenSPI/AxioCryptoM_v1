# Keil uVision project AxioCrypto.uvprojx, settings and files
target AxioCrypto (6230000::V6.23::ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: AxioCrypto
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: Stack_Size=0x1000 Heap_Size=0xE000
  c include: ..\..\..\M2351BSP\Library\Device\Nuvoton\M2351\Include;..\..\..\M2351BSP\Library\CMSIS\Include;..\..\..\M2351BSP\Library\StdDriver\inc;..\..\lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\m2351.sct
  link misc: --map --first='startup_M2351.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../M2351BSP/Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../M2351BSP/Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.S
  group User
    ../: main.c
  group Library
    ../../../M2351BSP/Library/StdDriver/src/: retarget.c sys.c clk.c uart.c fmc.c timer.c
  group AxioCryptoM
    ../../lib/include/: axiocrypto.h axiocrypto_defines.h
    ../../lib/: libaxiocrypto_1.0_m2351_ce.a
  group AxioCryptoM_Example
    ../../../axiocrypto_examples/: example.c example_axiocrypto.c example_util.c example_util.h
